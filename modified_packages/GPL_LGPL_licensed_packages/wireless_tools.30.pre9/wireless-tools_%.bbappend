# Install in usr/sbin as in previous image
EXTRA_OEMAKE += " 'INSTALL_DIR=${D}${sbindir}' "
